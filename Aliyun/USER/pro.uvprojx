# Keil uVision project pro.uvprojx, settings and files
target pro (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: pro +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS;..\USER;..\DEVICE_LIB\inc;..\SYSTEM;..\HARDWARE;..\FreeRTOS\include;..\FreeRTOS\portable;..\ESP8266;..\CJSON;..\DISPLAY;..\MPU6050
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/: startup_stm32f40_41xxx.s
  group DEVICE_LIB
    ../DEVICE_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_rtc.c stm32f4xx_pwr.c stm32f4xx_adc.c
  group HEADWARE
    ../HARDWARE/: Serial.h Serial.c LED.h LED.c DHT11.h DHT11.c MQADC.h MQADC.c MP3.h MP3.c SIM900A.h SIM900A.c Beep.h Beep.c BlueTooth.h BlueTooth.c Fire.h Fire.c HCSR312.h HCSR312.c RTC.h RTC.c Key.h Key.c
  group SYSTEM
    ../SYSTEM/: stm32f4xx.h system_stm32f4xx.h system_stm32f4xx.c Delay.h Delay.c sys.h sys.c
  group USER
    ./: main.h main.c stm32f4xx_it.c
  group FreeRTOS_SOURCE
    ../FreeRTOS/source/: list.c queue.c tasks.c timers.c event_groups.c
  group FreeRTOS_PORTABLE
    ../FreeRTOS/portable/: heap_4.c port.c
  group ESP8266
    ../ESP8266/: ESP8266.h ESP8266.c
  group CJSON
    ../CJSON/: cJSON.h cJSON.c
  group DISPLAY
    ../DISPLAY/: lcd.h lcd.c lcd_init.h lcd_init.c lcdfont.h OLED.h OLED.c OLED_Chinese.h OLED_Font.h
  group MPU6050
    ../MPU6050/: dmpKey.h dmpmap.h inv_mpu.h inv_mpu.c inv_mpu_dmp_motion_driver.h inv_mpu_dmp_motion_driver.c MPU6050.h MPU6050.c IIC.h IIC.c
